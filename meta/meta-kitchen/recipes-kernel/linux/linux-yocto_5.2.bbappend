FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_core2-32-intel-common = " file://enable-b43.cfg"
